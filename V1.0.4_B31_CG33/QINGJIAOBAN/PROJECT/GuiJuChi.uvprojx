# Keil uVision project GuiJuChi.uvprojx, settings and files
target QingJiaoBan (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GuiJuChi +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CORE\ST;..\MCU\INC;..\MCU\SRC;..\USER;..\CLASS\SCR;..\CLASS\INC;..\FREERTOS\INC;..\FREERTOS\SRC;..\FREERTOS\PORT\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/ST/: core_cm3.c startup_stm32f10x_md.s
  group USER
    ../USER/: main.c system_stm32f10x.c stm32f10x_it.c
  group MCU
    ../MCU/SRC/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CLASS
    ../CLASS/SCR/: gpio_code.c spi_code.c iic_code.c usart_code.c data_code.c ads1110_code.c adc161_code.c lm9507_code.c
