# Keil uVision project STM32L151.uvprojx, settings and files
target STM32L151 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L151CBTxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L151 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xBA
  c include: ../Core/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../Drivers/CMSIS/Include;../Software/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l151xba.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_i2c.c stm32l1xx_hal_spi.c stm32l1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
  group User/Device
    ../Software/src/: oled_code.c oledfont.c usart_code.c adc_code.c at21c512_code.c pcf8563_code.c key_code.c param_code.c
  group User/App
    ../Software/src/: agreement_code.c App_code.c App_key.c Algorithm_code.c App_Eep.c
software components: CMSIS:CORE 5.6.0
